# Keil uVision project Sensor_Collection_Module.uvprojx, settings and files
target KL25Z Flash (6100001::V6.10.1::.\ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicUI
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Startup
    ./: startup_MKL25Z4.s
    ./src/: system_MKL25Z4.c
  group source
    ./src/: main.c switches.c LEDs.c debug_signals.c infared.c motor_control.c serial.c logger.c
    ./: ultrasonic.c
software components: CMSIS:CORE 5.1.2
